# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h MatrixKey.c MatrixKey.h MatrixLED.c MatrixLED.h Nixie.c Nixie.h Timer0.c Timer0.h UART.c UART.h I2C.h I2C.c AT24C02.h AT24C02.c CheckPassword.c CheckPassword.h Cmd_Process.c Cmd_Process.h
